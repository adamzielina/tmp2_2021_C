# Keil uVision project Proj_Zielina_Guza_pt1250.uvprojx, settings and files
target Proj_Zielina_Guza_pt1250 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x00008000) IRAM(0x1FFFFC00,0x00001000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Proj_Zielina_Guza_pt1250
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./: ADC.c i2c.c lcd1602.c main.c pit.c klaw.c uart0.c tpm_pcm.c
  group irc
    ./: ADC.h frdm_bsp.h i2c.h lcd1602.h pit.h klaw.h uart0.h tpm_pcm.h music_samples.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
